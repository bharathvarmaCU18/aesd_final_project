# Enable fontconfig support in Qt
PACKAGECONFIG:append = " fontconfig"
